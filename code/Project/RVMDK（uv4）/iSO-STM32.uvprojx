# Keil uVision project iSO-STM32.uvprojx, settings and files
target Helmet (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Helmet +hex
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\Bluetooth;..\..\User\FATFS;..\..\User\OV7725;..\..\User\sdfs_app;..\..\ff11a\src;..\..\SYSTEM\sys;..\..\SYSTEM\delay;..\..\User\Sleep;..\..\User\MPU-6050;..\..\SYSTEM;..\..\User\answerPhone;..\..\User\debug;..\..\SYSTEM\usart;..\..\User\OV2640;..\..\User\sdfs_app;..\..\User\MALLOC;..\..\User\GPRS;..\..\User\GPS;..\..\User\judge;..\..\User\Beep
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ../../User/MPU-6050/: MPU-6050.c
    ../../User/Bluetooth/: Bluetooth.c
    ../../User/sdfs_app/: sdfs_app.c
    ../../User/OV2640/: ov2640.c
    ../../User/GPS/: gps.c uart4.c
    ../../User/judge/: judge.c
    ../../User/Beep/: beep.c
  group Drive
    ../../User/FATFS/: sd.c spi.c
    ../../User/OV7725/: sccb.c
    ../../User/Bluetooth/: usart.c uart5.c
    ../../User/MALLOC/: malloc.c
  group FatFs
    ../../ff11a/src/: diskio.c ff.c
  group SYSTEM
    ../../SYSTEM/delay/: delay.c
    ../../SYSTEM/sys/: sys.c
  group Sleep
    ../../User/Sleep/: exti.c gpio.c
  group answerPhone
    ../../User/answerPhone/: answer.c
  group debug
    ../../User/debug/: debug.c
  group GPRS
    ../../User/GPRS/: bsp_usart3.c sim900a.c
